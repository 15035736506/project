# IAR project car.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 120
  General.GHeapSize2: 120
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ucos-ii\CPU_port; ucos-ii\source; user; APP; BSP; USART
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    user/: APP_cfg.h includes.h
    APP/: APP_main2.c speed.c speed.h
  group BSP
    user/: delay.h
    BSP/: motor.c motor.h
  group ucos-ii/CPU
    ucos-ii/CPU_port/: os_cfg.h OS_CPU.H OS_CPU_A.asm Os_cpu_c.c
  group ucos-ii/source
    ucos-ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c ucos_ii.h
  group USART
    USART/: USART.c USART.h
