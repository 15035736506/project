# Keil uVision project lwip.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lwip
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\APP;..\BSP;..\CMSIS;..\CMSIS\startup;..\FWlib\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\user;..\enc28j60;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\src\include\netif;..\lwip-1.4.1\src\include\posix;..\lwip-1.4.1\src\include\posix\sys;..\lwip-1.4.1\src\include;..\lwip-1.4.1;..\lwip-1.4.1\ARCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group user
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/: BSP.c led.c
  group APP
    ../APP/: app.c udp_config_APP.c httpd.c
  group ucos-ii\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-ii\Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group enc28j60
    ../enc28j60/: ENC28J60.C SPI.C
  group lwip/api
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/core/ipv4
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/core/snmp
    ../lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip/netif
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group SENSOR
    ../BSP/: Imag_App.c OV7725.c SCCB.c SensorConfig.c usart1.c
