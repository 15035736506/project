# Keil uVision project Project_uV4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project_uV4
  c flags: Optim=1 OneElfS=1
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\app;.\app\UipServer;.\uIP-1.0\uip;.\uIP-1.0\apps\webserver;.\app\arch;.\Drivers\DM9000CEP;.\uIP-1.0\apps\webserver;.\uIP-1.0\apps\dhcpc;.\uIP-1.0\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./app/: main.c
  group Libraries\STM32F10x_StdPeriph_Lib_V3.5.0
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Libraries\CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries\Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group uIP-1.0
    ./uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group App\Arch
    ./app/arch/: clock-arch.c systick.c tapdev.c stm32f10x_it.c
  group App\UipServer
    ./app/UipServer/: server.c tcp_demo.c udp_demo.c
  group Drivers\DM9000CEP
    ./Drivers/DM9000CEP/: dm9000x.c
  group uIP-1.0\apps\webserver
    ./uIP-1.0/apps/webserver/: http-strings.c httpd.c httpd-cgi.c httpd-fs.c
  group uIP-1.0\apps\dhcpc
    ./uIP-1.0/apps/dhcpc/: dhcpc.c
  group uIP-1.0\lib
    ./uIP-1.0/lib/: memb.c
